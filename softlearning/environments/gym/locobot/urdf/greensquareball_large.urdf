Commit message: larger ball

File: softlearning/environments/gym/locobot/urdf/greensquareball_large.urdf (robot description, URDF)
Before this commit: robot squareball, 1 links, 0 joints
Links:
- link origin: geometry collision box size=0.01 0.01 0.03; collision box size=0.01 0.03 0.01
